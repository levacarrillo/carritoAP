Commit message: Added full sensors

File: catkin_ws/src/rob2w_description/src/urdf/carritoAP.urdf (robot description, URDF)
Before this commit: robot carritoAP, 6 links, 5 joints
Joints:
- joint laser_joint: origin xyz=0.06323 0 0.04 rpy=0 0 0 -> xyz=0 0 0.04 rpy=0 0 0
